# IAR project driverlib_empty_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; TARGET_IS_MSP432P4XX; __MSP432P401R__; USE_CMSIS_REGISTER_FORMAT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ; driverlib\MSP432P4xx; inc\; $TOOLKIT_DIR$\inc\TexasInstruments; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ; driverlib\MSP432P4xx\
  OBJCOPY.OOCOutputFile: driverlib_empty_project.bin
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: driverlib_empty_project_ewarm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    driverlib/MSP432P4xx/ewarm/: msp432p4xx_driverlib.a
  group Source
    ./: clase_functions.cpp configs.cpp serial_b.cpp startup_msp432p401r_ewarm.c system_msp432p401r.c
